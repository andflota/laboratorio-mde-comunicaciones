options:
  parameters:
    author: Edwar_Camargo_Andres_Tarazona
    copyright: Edwar_Camargo_Andres_Tarazona
    generate_options: qt_gui
    id: Modulacion_PM
    output_language: python
    title: Modulacion_PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '0.000001'
    stop: '2'
    value: '0.25'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: G_T_X
  id: variable_qtgui_range
  parameters:
    label: Ganancia Del Transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Mensaje
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12500000'
  states: {}
- name: EnvolventeCompleja_PM_0
  id: EnvolventeCompleja_PM
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: G_T_X
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventeCompleja_PM_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeCompleja_PM_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventeCompleja_PM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeCompleja_PM_0, '0']

metadata:
  file_format: 1
