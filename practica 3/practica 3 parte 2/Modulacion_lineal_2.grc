options:
  parameters:
    author: Andres_Florez_Edwar_Camargo
    copyright: Andres_Florez_Edwar_Camargo
    generate_options: qt_gui
    id: Modulacion_lineal_2
    output_language: python
    title: TRANSMISION AM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud modulante
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la portadora
    orient: Qt.Horizontal
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: G_T_X
  id: variable_qtgui_range
  parameters:
    label: Ganancia del tx
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: Modulacion_Lineal_0
  id: Modulacion_Lineal
  parameters:
    Ac: Ac
    ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: Fc
    dev_args: '""'
    gain0: G_T_X
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulacion_Lineal_0, '0', qtgui_time_sink_x_0, '0']
- [Modulacion_Lineal_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Modulacion_Lineal_0, '0']

metadata:
  file_format: 1
